# Keil uVision project cordic.uvprojx, settings and files
target FLASH (6100001::V6.10.1::.\ARMCLANG)
  device: MDR1986VK01 Milandr
  pack: Keil.MDR1986VK01.1.3
  cpu: IRAM(0x02000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x01000000,0x00100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: pwm_rgb
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x2000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group usr
    ./: main.c
target RAM (6100001::V6.10.1::.\ARMCLANG)
  device: MDR1986VK01 Milandr
  pack: Keil.MDR1986VK01.1.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x2000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: pwm_rgb
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x2000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.3

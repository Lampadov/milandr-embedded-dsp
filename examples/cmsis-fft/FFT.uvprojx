# Keil uVision project FFT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F1QI Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: HelloWorld +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_DSP_CONFIG_TABLES, ARM_FFT_ALLOW_TABLES, ARM_FAST_ALLOW_TABLES, ARM_ALL_FAST_TABLES, ARM_TABLE_TWIDDLECOEF_F32_512, ARM_TABLE_BITREVIDX_FLT_512, ARM_TABLE_TWIDDLECOEF_RFFT_F32_1024
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 2.0.2i, Drivers:PORT 2.0.2i, Drivers:RST_CLK 2.0.2i
